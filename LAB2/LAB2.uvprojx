# Keil uVision project LAB2.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LAB2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: ds18b20.h ds18b20.c main.c uart.h uart.c
software components: CMSIS:CORE 6.1.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:GPIO 1.3, Device:Startup 1.0.0
